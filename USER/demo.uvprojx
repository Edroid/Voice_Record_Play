# Keil uVision project demo.uvprojx, settings and files
target demo (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\CORE;.\inc;..\HARDWARE\ADC;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\led;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\flash;..\HARDWARE\key;..\HARDWARE\led;..\HARDWARE\timer;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HARDWARE
    ../HARDWARE/led/: stm32f4_led.c
    ../HARDWARE/ADC/: stm32f4_adc.c
    ../HARDWARE/DAC/: stm32f4_dac.c
    ../HARDWARE/flash/: stm32f4_flash.c
    ../HARDWARE/key/: stm32f4_key.c
    ../HARDWARE/timer/: stm32f4_timer.c
  group USER
    ./src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f4xx.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
